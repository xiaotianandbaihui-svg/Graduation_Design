# Keil uVision project RemoteController.uvprojx, settings and files
target TOUCH (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: TOUCH +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\LED;..\HARDWARE\LCD;..\HARDWARE\KEY;..\HARDWARE\IIC;..\HARDWARE\24CXX;..\FWLIB\inc;..\HARDWARE\TOUCH;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\FreeRTOS;..\MIDDLEWARE;..\MIDDLEWARE\LVGL\GUI;..\MIDDLEWARE\LVGL\GUI\lvgl;..\MIDDLEWARE\LVGL\GUI\lvgl\src;..\MIDDLEWARE\LVGL\GUI\lvgl\examples\porting
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c app_tasks.c app_tasks.h task_config.c task_config.h remote_control.c remote_control.h remote_dashboard.c remote_dashboard.h remote_ui.c remote_ui.h remote_font.c remote_font.h
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/24CXX/: 24cxx.c
    ../HARDWARE/TOUCH/: ctiic.c gt9147.c ott2001a.c ft5206.c touch.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_fsmc.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_dma.c
  group FreeRTOS
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c FreeRTOSConfig.h heap_4.c port.c
  group MIDDLEWARE\LVGL\GUI\lvgl\examples\porting
    ../MIDDLEWARE/LVGL/GUI/lvgl/examples/porting/: lv_port_disp_template.c lv_port_indev_template.c
  group MIDDLEWARE\LVGL\GUI\lvgl\src\core
    ../MIDDLEWARE/LVGL/GUI/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
  group MIDDLEWARE\LVGL\GUI\lvgl\src\draw
    ../MIDDLEWARE/LVGL/GUI/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c
    ../MIDDLEWARE/LVGL/GUI/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
  group MIDDLEWARE\LVGL\GUI\lvgl\src\extra
    ../MIDDLEWARE/LVGL/GUI/lvgl/src/extra/libs/bmp/: lv_bmp.c
    ../MIDDLEWARE/LVGL/GUI/lvgl/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ../MIDDLEWARE/LVGL/GUI/lvgl/src/extra/libs/freetype/: lv_freetype.c
    ../MIDDLEWARE/LVGL/GUI/lvgl/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../MIDDLEWARE/LVGL/GUI/lvgl/src/extra/libs/gif/: gifdec.c lv_gif.c
    ../MIDDLEWARE/LVGL/GUI/lvgl/src/extra/libs/png/: lodepng.c lv_png.c
    ../MIDDLEWARE/LVGL/GUI/lvgl/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../MIDDLEWARE/LVGL/GUI/lvgl/src/extra/libs/rlottie/: lv_rlottie.c
    ../MIDDLEWARE/LVGL/GUI/lvgl/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../MIDDLEWARE/LVGL/GUI/lvgl/src/extra/layouts/flex/: lv_flex.c
    ../MIDDLEWARE/LVGL/GUI/lvgl/src/extra/layouts/grid/: lv_grid.c
    ../MIDDLEWARE/LVGL/GUI/lvgl/src/extra/others/gridnav/: lv_gridnav.c
    ../MIDDLEWARE/LVGL/GUI/lvgl/src/extra/others/monkey/: lv_monkey.c
    ../MIDDLEWARE/LVGL/GUI/lvgl/src/extra/others/snapshot/: lv_snapshot.c
    ../MIDDLEWARE/LVGL/GUI/lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ../MIDDLEWARE/LVGL/GUI/lvgl/src/extra/themes/default/: lv_theme_default.c
    ../MIDDLEWARE/LVGL/GUI/lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ../MIDDLEWARE/LVGL/GUI/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../MIDDLEWARE/LVGL/GUI/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../MIDDLEWARE/LVGL/GUI/lvgl/src/extra/widgets/chart/: lv_chart.c
    ../MIDDLEWARE/LVGL/GUI/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../MIDDLEWARE/LVGL/GUI/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../MIDDLEWARE/LVGL/GUI/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ../MIDDLEWARE/LVGL/GUI/lvgl/src/extra/widgets/led/: lv_led.c
    ../MIDDLEWARE/LVGL/GUI/lvgl/src/extra/widgets/list/: lv_list.c
    ../MIDDLEWARE/LVGL/GUI/lvgl/src/extra/widgets/menu/: lv_menu.c
    ../MIDDLEWARE/LVGL/GUI/lvgl/src/extra/widgets/meter/: lv_meter.c
    ../MIDDLEWARE/LVGL/GUI/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../MIDDLEWARE/LVGL/GUI/lvgl/src/extra/widgets/span/: lv_span.c
    ../MIDDLEWARE/LVGL/GUI/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../MIDDLEWARE/LVGL/GUI/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../MIDDLEWARE/LVGL/GUI/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../MIDDLEWARE/LVGL/GUI/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ../MIDDLEWARE/LVGL/GUI/lvgl/src/extra/widgets/win/: lv_win.c
    ../MIDDLEWARE/LVGL/GUI/lvgl/src/extra/: lv_extra.c
  group MIDDLEWARE\LVGL\GUI\lvgl\src\font
    ../MIDDLEWARE/LVGL/GUI/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
  group MIDDLEWARE\LVGL\GUI\lvgl\src\gpu
    ../MIDDLEWARE/LVGL/GUI/lvgl/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
    ../MIDDLEWARE/LVGL/GUI/lvgl/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
  group MIDDLEWARE\LVGL\GUI\lvgl\src\hal
    ../MIDDLEWARE/LVGL/GUI/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group MIDDLEWARE\LVGL\GUI\lvgl\src\misc
    ../MIDDLEWARE/LVGL/GUI/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
  group MIDDLEWARE\LVGL\GUI\lvgl\src\widgets
    ../MIDDLEWARE/LVGL/GUI/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
